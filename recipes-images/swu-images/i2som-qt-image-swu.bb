# Copyright (C) 2017 i2SOM Team.

require swu.inc

#IMG_NAME = "${@get_baseimg_pn(d)}-${GRAPHICAL_BACKEND}"
IMG_NAME = "${@get_baseimg_pn(d)}"
