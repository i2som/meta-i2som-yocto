# Copyright (C) 2017 i2SOM Team.

FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"
